# Keil uVision project DryMachine.uvprojx, settings and files
target DryMachine (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: DryMachine +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../App/board;../App/control;../App/drivers/button;../App/drivers/flash_store;../App/drivers/ili9341;../App/drivers/max31865;../App/drivers/ntc;../App/drivers/relay;../App/drivers/sht4x;../App/services;../App/ui
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c rtc.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App/app
    ../App/: app.c
  group App/board
    ../App/board/: board.c
  group App/drivers
    ../App/drivers/button/: button.c
    ../App/drivers/flash_store/: flash_store.c
    ../App/drivers/ili9341/: font5x7.c fonts_vn.c ili9341.c ili9341_text.c
    ../App/drivers/max31865/: max31865.c
    ../App/drivers/ntc/: ntc.c
    ../App/drivers/relay/: relay.c
    ../App/drivers/sht4x/: sht4x.c
  group App/services
    ../App/services/: datetime.c fault_log.c log.c presets.c sched.c sensors.c settings.c sim_plant.c util_fmt.c
  group App/control
    ../App/control/: dryer_ctrl.c fan_speed.c
  group App/ui
    ../App/ui/: ui_core.c ui_edit.c ui_list.c ui_menu_preset.c ui_page_fan.c ui_page_faults.c ui_page_main.c ui_page_outputs.c ui_page_run.c ui_page_timer.c ui_widgets.c
software components: CMSIS:CORE 4.3.0
